Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-07-31T10:52:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 31 10:52:27 2019 * Host: PROMAN1-RO-DE * Database: C:\Users\PRoman1\AppData\Local\Temp\{6672D707-6C19-41FB-B997-FCC08ED14B2E}\ifc * Database version: 5507 * Database creation date: Wed Jul 31 10:52:25 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jul 31 10:52:26 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 31 10:52:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: ecoCRAFT exclusive VKK 2006/3-E HL R1, HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoCRAFT exclusiv_HR-HR:ecoCRAFT exclusive VKK 2006/3-E HL R1:1287235
In: V00
Type - Material: Color RGB 121-121-121, Color RGB 244-244-244, Color RGB 116-051-029
Type - Dimensions - Offset: 0 mm; Condensate Connection: 32 mm; Depth: 1500 mm; Flue Gas Diameter: 200 mm; Gas Diameter: 38.1 mm; Height: 1289.5 mm; Hydronic Return Diameter: 50.8 mm; Hydronic Supply Diameter: 50.8 mm; Legs Offset: 1118 mm; Supply Air Diameter: 130 mm; Use Nominal Diameter: yes; Width: 695 mm
Type - Electrical - Loads - Voltage: 230.002 V
Type - Identity Data - Article Description: Viskoučinski kondnezacijski plinski kotao velikog učina; Article Type: ecoCRAFT exclusive VKK 2006/3-E HL R1; Base Family Version: 12.04; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Kompaktni kondenzacijski kotao; EMCS Version: 3.0; ETIM Article Class: EC011396; Family Version: 12.04; GTIN: 4024074707401; Manufacturer: Vaillant; Manufacturer Art. No.: 0010016463; Manufacturer URL: https://www.vaillant.hr/krajnji-korisnici/proizvodi/ecocraft-exclusive-vkk-806-3-e-hl-int-2806-3-e-hl-int-835.html; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: ecoCRAFT exclusive VKK 2006/3-E HL R1; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: ecoCRAFT exclusiv; Revit Version: 2018; Type Name: ecoCRAFT exclusive VKK 2006/3-E HL R1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Connection Pipes: Color RGB 116-051-029; Grey: Color RGB 121-121-121; White: Color RGB 244-244-244
Type - Mechanical - Tap Capacity at 40°C: 0 m3/s
Type - Mechanical - Loads - Heating Power: 2109726
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoCRAFT exclusiv_HR-HR; Flue Gas Connection: 215 mm; Service Area Length: 2193.1 mm
Type - Text - Pipe Type Category: M561
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 14.772 m2; Height Legs: 10 mm; Volume: 1.31593 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s; System Classification: Supply Air,Hydronic Return,Sanitary,Hydronic Supply,Undefined,Power
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoCRAFT exclusiv_HR-HR: ecoCRAFT exclusive VKK 2006/3-E HL R1; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoCRAFT exclusiv_HR-HR: ecoCRAFT exclusive VKK 2006/3-E HL R1; Height Legs Geometry: 10 mm; Height Legs Safe: 10 mm; Legs: yes; Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoCRAFT exclusiv_HR-HR: ecoCRAFT exclusive VKK 2006/3-E HL R1; Type Id: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoCRAFT exclusiv_HR-HR: ecoCRAFT exclusive VKK 2006/3-E HL R1
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
